# Keil uVision project BaseMobile1.uvproj, settings and files
target BaseMobile1 Configuration (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BaseMobile1 Configuration
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;                                                                           ..\Drivers\STM32F4xx_HAL_Driver\Inc;                                                                           ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;                                                                           ..\Drivers\CMSIS\Include;                                                                           ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c gpio.c main.c tim.c US_Capteur.c Moteurs.c i2c.c Tempo.c LCD16x2.c Boutons.c adc.c Temperature.c usart.c HMC5883L.c dma.c spi.c spi_flash.c Sauve_Restaure.c Batterie.c Phares.c WifiCom.c Rplidar.c Kalman.c MPU6050.c Guidage.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
